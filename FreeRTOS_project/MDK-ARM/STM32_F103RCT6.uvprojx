# Keil uVision project STM32_F103RCT6.uvprojx, settings and files
target STM32_F103RCT6 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_F103RCT6 +hex
  AfterMake: fromelf --bin !L -o .\output\app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,STM32F103x
  c include: ..\app\inc;..\bsp\inc;..\cmsis\inc;..\mcu\Inc;..\thirdpart\cm_backtrace;..\MDK-ARM;..\utils\inc;..\RTOS\Source\portable\RVDS\ARM_CM3;..\RTOS\inc;..\RTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c
  group bsp
    ../bsp/src/: bsp_gpio.c bsp_uart.c bsp_flash.c bsp_timer.c bsp_systick.c
  group app
    ../app/src/: app_task.c app_led.c app_procotol.c
  group freertos
    ../RTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../RTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../RTOS/Source/portable/MemMang/: heap_4.c
  group utils
    ../utils/src/: ring_buffer.c common.c protocol.c
  group device_lib
    ../mcu/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f1xx_it.c
  group Com_backtrace
    ../thirdpart/cm_backtrace/: cm_backtrace.c
    ../thirdpart/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group CMSIS
    ../cmsis/src/: system_stm32f10x.c startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.6.0
